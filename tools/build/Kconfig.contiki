## tools/build/Kconfig.contiki
```kconfig
config CONTIKI
    def_bool y
    select FEATURE_COAP
    select FEATURE_FLOW
    select FEATURE_HW_GPIO
    select FEATURE_NETWORK
```
